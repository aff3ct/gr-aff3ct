options:
  parameters:
    author: gr-aff3ct
    category: Custom
    generate_options: qt_gui
    id: aff3ct_turbo_ber
    output_language: python
    title: 'AFF3CT turbo code: BER on AWGN'
  states: {}

blocks:
- name: berminerrs
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: sigma
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1, -1]'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: berminerrs
    test_mode: 'False'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    label1: ''
    legend: 'False'
    marker1: '0'
    name: ''
    size: '1024'
    srate: samp_rate
    style1: '3'
    type: float
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: K
  id: variable
  parameters:
    value: '424'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1284'
  states: {}
- name: sigma
  id: variable
  parameters:
    value: numpy.sqrt(1.0 / (2.0 * K / N * 10.0**(ebn0 / 10.0)))
  states: {}
- name: ebn0
  id: variable_qtgui_range
  parameters:
    label: Eb/N0 (dB)
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1.5'
  states: {}
- name: enc
  id: aff3ct_turbo_encoder_def
  parameters:
    ndim: '0'
    dim1: '1'
    dim2: '1'
    K: K
    N: N
    interleaver: AUTO
    seed: '0'
    aff3ct_args: ''''''
  states: {}
- name: dec
  id: aff3ct_turbo_decoder_def
  parameters:
    ndim: '1'
    dim1: '2'
    dim2: '1'
    K: K
    N: N
    n_ite: '6'
    interleaver: AUTO
    seed: '0'
    precision: int16
    simd: INTER
    frames: '0'
    llr_scale: '1.0'
    aff3ct_args: ''''''
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2.0 / sigma**2
    type: float
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fec_extended_decoder_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', blocks_add_xx_0, '1']
- [blocks_pack_k_bits_bb_0, '0', fec_ber_bf_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle_0, '0', fec_ber_bf_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fec_extended_decoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_extended_encoder_0, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
